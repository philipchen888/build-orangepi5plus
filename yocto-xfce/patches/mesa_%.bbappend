PACKAGECONFIG:append:rk3288 = " kmsro panfrost"
PACKAGECONFIG:append:rk3399 = " kmsro panfrost"
PACKAGECONFIG:append:rock64 = " kmsro lima"
PACKAGECONFIG:append:px30 = " kmsro panfrost"
PACKAGECONFIG:append:orangepi-5-plus = " panfrost"
